# Keil uVision project Blinky.uvprojx, settings and files
target ADuCM355 (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: ADuCM355 Analog Devices
  pack: AnalogDevices.ADuCM355_DFP.1.0.4
  cpu: IRAM(0x20000000,0x02000) IRAM2(0x20002000,0x02000) IROM(0x00000000,0x20000) XRAM(0x20004000,0x04000) XRAM2(0x20040000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M355_RTC
  BeforeMake: powershell.exe -ExecutionPolicy RemoteSigned "..\build.ps1"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: CHIPSEL_M355, PLATFORM_ADUCM355, SCHEDULER_DYNAMIC, LF_LOG_CARRIAGE_RETURN, LF_LOG_LEVEL_ALL=LF_LOG_LEVEL_INFO
  c include: ..\src-gen\Blinky\reactor-uc\include;..\src-gen\Blinky
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x20004000 size 0x4000
  memory RVCT7: RAM 0x20040000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x20002000 size 0x2000
  scatter file: 64KSRAM.sct
  group app
    ../src-gen/Blinky/: lf_main.c lf_start.c
    ../src-gen/Blinky/Blinky/: Blinky.c
  group reactor-uc
    ../src-gen/Blinky/reactor-uc/src/: action.c builtin_triggers.c connection.c environment.c event.c logging.c platform.c port.c queues.c reaction.c reactor.c scheduler.c tag.c timer.c trigger.c util.c
  group lf
    ../src/: Blinky.lf
software components: CMSIS:CORE 5.6.0, Device:AFE:Operation 0.9.4, Device:Peripheral Libraries:CLOCK 0.9.4, Device:Peripheral Libraries:GPIO 0.9.4, Device:Peripheral Libraries:INT 0.9.4, Device:Peripheral Libraries:PWR 0.9.4, Device:Peripheral Libraries:RTC 0.9.4, Device:Peripheral Libraries:Timer 0.9.4, Device:Peripheral Libraries:UART 0.9.4, Device:Retarget UART 0.9.4, Device:Startup 0.9.4
